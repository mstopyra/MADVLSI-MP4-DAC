** sch_path: schemas/2-1-MUX.sch
**.subckt 2-1-MUX Din1 Din0 S Dout
*.ipin Din1
*.ipin Din0
*.ipin S
*.opin Dout
XM2 Dout net1 Din0 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 Din1 S Dout VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 Dout S Din0 GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 Din1 net1 Dout GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 net1 net1 inv
**.ends

* expanding   symbol:  /home/mstopyra/Documents/MADVLSI-MP4-DAC/schemas/inv.sym # of pins=2
** sym_path: /home/mstopyra/Documents/MADVLSI-MP4-DAC/schemas/inv.sym
** sch_path: /home/mstopyra/Documents/MADVLSI-MP4-DAC/schemas/inv.sch
.subckt inv OUT[expr(@width - 1):0] IN[expr(@width - 1):0]
*.ipin IN[@width - 1:0]
*.opin OUT[@width - 1:0]
M1[@width - 1:0] OUT[@width - 1:0] IN[@width - 1:0] GND GND cmosn w=2u l=1u m=1
M2[@width -1:0] OUT[@width - 1:0] IN[@width - 1:0] VDD VDD cmosp w=5u l=1u m=1
.ends

.GLOBAL VDD
.GLOBAL GND
.end
